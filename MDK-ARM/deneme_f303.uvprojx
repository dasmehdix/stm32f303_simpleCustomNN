# Keil uVision project deneme_f303.uvprojx, settings and files
target deneme_f303 (ARM-ADS)
  device: STM32F303K8Tx STMicroelectronics
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: deneme_f303 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303x8
  c include: ../X-CUBE-AI/App; ../X-CUBE-AI; ../Core/Inc; ../Middlewares/ST/AI/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32f303x8.s
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: network_deneme_1.c network_deneme_1_data.c app_x-cube-ai.c
  group Application/User/Core
    ../Core/Src/: main.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Doc
    ../X-CUBE-AI/App/: network_deneme_1_generate_report.txt
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime512_CM4_Keil.lib
software components: CMSIS:CORE 4.3.0
